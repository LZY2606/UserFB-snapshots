// Native (desktop) counterpart of examples/DecodeFromProgmem and
// examples/EncodeSyntheticFrame's built-in benchmarks - same clip, same
// synthetic gradient, same repetition counts and first-frame exclusion, just
// timed with std::chrono instead of Arduino's micros(), so this project's
// README/docs/memory-budget.md can report real x86 numbers alongside the
// real ESP32 ones without fabricating either. Not a correctness test (no
// assertions, not added to CTest in CMakeLists.txt) - build/run manually:
//   cmake --build build --target bench_native && ./build/test/native/bench_native
#include <chrono>
#include <cstdint>
#include <cstdio>

#include "TinyMPGDecoder.h"
#include "TinyMPGEncoder.h"

using namespace tinympg;

static uint64_t nowUs() {
  return std::chrono::duration_cast<std::chrono::microseconds>(
             std::chrono::steady_clock::now().time_since_epoch())
      .count();
}

// --- decode benchmark: identical clip to examples/DecodeFromProgmem/mpg_test_clip.h ---
static const uint32_t kTestClipSize = 525;
static const uint8_t kTestClip[] = {
    0x00, 0x00, 0x01, 0xB3, 0x0B, 0x00, 0x90, 0x13, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x01, 0xB8,
    0x00, 0x08, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0x01,
    0x43, 0x5A, 0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29, 0x11, 0x72, 0x94, 0xA4, 0x45,
    0xCA, 0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29, 0x11, 0x72, 0x94, 0xA4, 0x45, 0xCA,
    0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29, 0x11, 0x72, 0x94, 0xA4, 0x45, 0xCA, 0x52,
    0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29, 0x11, 0x72, 0x94, 0xA4, 0x45, 0xCA, 0x52, 0x91,
    0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29, 0x11, 0x72, 0x94, 0xA4, 0x45, 0xCA, 0x52, 0x91, 0x17,
    0x29, 0x4A, 0x44, 0x40, 0x00, 0x00, 0x01, 0x03, 0x43, 0x5A, 0x52, 0x91, 0x17, 0x29, 0x4A, 0x44,
    0x5C, 0xA5, 0x29, 0x11, 0x72, 0x94, 0xA4, 0x45, 0xCA, 0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C,
    0xA5, 0x29, 0x11, 0x72, 0x94, 0xA4, 0x45, 0xCA, 0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5,
    0x29, 0x11, 0x72, 0x94, 0xA4, 0x45, 0xCA, 0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29,
    0x11, 0x72, 0x94, 0xA4, 0x45, 0xCA, 0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29, 0x11,
    0x72, 0x94, 0xA4, 0x45, 0xCA, 0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x40, 0x00, 0x00, 0x01, 0x05,
    0x43, 0x5A, 0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29, 0x11, 0x72, 0x94, 0xA4, 0x45,
    0xCA, 0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29, 0x11, 0x72, 0x94, 0xA4, 0x45, 0xCA,
    0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29, 0x11, 0x00, 0x00, 0x00, 0x01, 0x06, 0x43,
    0x5A, 0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29, 0x11, 0x72, 0x94, 0xA4, 0x45, 0xCA,
    0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29, 0x11, 0x72, 0x94, 0xA4, 0x45, 0xCA, 0x52,
    0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29, 0x11, 0x72, 0x94, 0xA4, 0x45, 0xCA, 0x52, 0x91,
    0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29, 0x11, 0x72, 0x94, 0xA4, 0x45, 0xCA, 0x52, 0x91, 0x17,
    0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29, 0x11, 0x72, 0x94, 0xA4, 0x45, 0xCA, 0x52, 0x91, 0x17, 0x29,
    0x4A, 0x44, 0x40, 0x00, 0x00, 0x01, 0x08, 0x43, 0x5A, 0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C,
    0xA5, 0x29, 0x11, 0x72, 0x94, 0xA4, 0x45, 0xCA, 0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5,
    0x29, 0x11, 0x72, 0x94, 0xA4, 0x45, 0xCA, 0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29,
    0x11, 0x72, 0x94, 0xA4, 0x45, 0xCA, 0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29, 0x11,
    0x72, 0x94, 0xA4, 0x45, 0xCA, 0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x5C, 0xA5, 0x29, 0x11, 0x72,
    0x94, 0xA4, 0x45, 0xCA, 0x52, 0x91, 0x17, 0x29, 0x4A, 0x44, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
    0x57, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x01, 0x01, 0x42, 0x70, 0x48, 0xE0, 0x00, 0x00, 0x01, 0x03,
    0x42, 0x70, 0x48, 0xE0, 0x00, 0x00, 0x01, 0x05, 0x42, 0x70, 0xB3, 0x80, 0x00, 0x00, 0x01, 0x06,
    0x42, 0x70, 0x48, 0xE0, 0x00, 0x00, 0x01, 0x08, 0x42, 0x70, 0x48, 0xE0, 0x00, 0x00, 0x01, 0x00,
    0x00, 0x97, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x01, 0x01, 0x42, 0x70, 0x48, 0xE0, 0x00, 0x00, 0x01,
    0x03, 0x42, 0x70, 0x48, 0xE0, 0x00, 0x00, 0x01, 0x05, 0x42, 0x70, 0xB3, 0x80, 0x00, 0x00, 0x01,
    0x06, 0x42, 0x70, 0x48, 0xE0, 0x00, 0x00, 0x01, 0x08, 0x42, 0x70, 0x48, 0xE0,
};

static const int kDecodeBenchmarkReps = 30;

static uint64_t checkpointUs = 0;
static int frameCount = 0;
static uint64_t totalDecodeUs = 0;
static uint64_t minDecodeUs = UINT64_MAX, maxDecodeUs = 0;

static void onFrame(TinyMPGDecoder<>& /*d*/, void* /*userData*/) {
  uint64_t frameUs = nowUs() - checkpointUs;
  frameCount++;
  if (frameCount > 1) {  // exclude first frame's one-time setup cost, same as the .ino examples
    totalDecodeUs += frameUs;
    if (frameUs < minDecodeUs) minDecodeUs = frameUs;
    if (frameUs > maxDecodeUs) maxDecodeUs = frameUs;
  }
  checkpointUs = nowUs();
}

static void runDecodeBenchmark() {
  TinyMPGDecoder<> decoder;
  decoder.setCallback(onFrame);
  decoder.setMaxDimension(176, 144);

  checkpointUs = nowUs();
  for (int rep = 0; rep < kDecodeBenchmarkReps; rep++) {
    decoder.write(kTestClip, kTestClipSize);
    if (decoder.hasError()) {
      fprintf(stderr, "decode benchmark: decoder error, aborting\n");
      return;
    }
  }

  printf("Decoded %d frame(s) over %d repetition(s) of the clip.\n", frameCount,
         kDecodeBenchmarkReps);
  if (frameCount > 1) {
    uint64_t avgUs = totalDecodeUs / (uint64_t)(frameCount - 1);
    printf("Per-frame decode time: avg=%llu us (%.1f fps), min=%llu us (%.1f fps), max=%llu us (%.1f fps)\n",
           (unsigned long long)avgUs, 1000000.0 / (double)avgUs, (unsigned long long)minDecodeUs,
           1000000.0 / (double)minDecodeUs, (unsigned long long)maxDecodeUs,
           1000000.0 / (double)maxDecodeUs);
  }
}

// --- encode benchmark: identical pattern to examples/EncodeSyntheticFrame ---
static const int kWidth = 176;
static const int kHeight = 144;
static const int kQp = 8;
static const int kNumFrames = 4;
static const int kEncodeBenchmarkReps = 30;

static uint8_t srcY[kWidth * kHeight];
static uint8_t srcU[(kWidth / 2) * (kHeight / 2)];
static uint8_t srcV[(kWidth / 2) * (kHeight / 2)];
static uint8_t bitstream[16384];

static void makeTestPattern(int shiftX) {
  for (int y = 0; y < kHeight; y++) {
    for (int x = 0; x < kWidth; x++) {
      int v = ((x + shiftX + y) * 255) / (kWidth + kHeight);
      srcY[y * kWidth + x] = (uint8_t)(v & 0xFF);
    }
  }
  for (int i = 0; i < (kWidth / 2) * (kHeight / 2); i++) {
    srcU[i] = 128;
    srcV[i] = 128;
  }
}

static void runEncodeBenchmark() {
  TinyMPGEncoder<> encoder;
  if (!encoder.setSize(kWidth, kHeight) || !encoder.setQp(kQp)) {
    fprintf(stderr, "encode benchmark: setSize()/setQp() failed\n");
    return;
  }

  int frameCount2 = 0;
  uint64_t totalEncodeUs = 0;
  uint64_t minEncodeUs = UINT64_MAX, maxEncodeUs = 0;

  for (int rep = 0; rep < kEncodeBenchmarkReps; rep++) {
    for (int i = 0; i < kNumFrames; i++) {
      makeTestPattern(i * 8);
      uint64_t startUs = nowUs();
      size_t n = encoder.encodeFrame(srcY, srcU, srcV, bitstream, sizeof(bitstream));
      uint64_t encodeUs = nowUs() - startUs;
      frameCount2++;
      if (n == 0) {
        fprintf(stderr, "encode benchmark: encodeFrame() failed\n");
        continue;
      }
      if (frameCount2 > 1) {  // exclude first frame, same as the .ino example
        totalEncodeUs += encodeUs;
        if (encodeUs < minEncodeUs) minEncodeUs = encodeUs;
        if (encodeUs > maxEncodeUs) maxEncodeUs = encodeUs;
      }
    }
  }

  printf("Encoded %d frame(s) over %d repetition(s) of the sequence.\n", frameCount2,
         kEncodeBenchmarkReps);
  if (frameCount2 > 1) {
    uint64_t avgUs = totalEncodeUs / (uint64_t)(frameCount2 - 1);
    printf("Per-frame encode time: avg=%llu us (%.1f fps), min=%llu us (%.1f fps), max=%llu us (%.1f fps)\n",
           (unsigned long long)avgUs, 1000000.0 / (double)avgUs, (unsigned long long)minEncodeUs,
           1000000.0 / (double)minEncodeUs, (unsigned long long)maxEncodeUs,
           1000000.0 / (double)maxEncodeUs);
  }
}

int main() {
  runDecodeBenchmark();
  runEncodeBenchmark();
  return 0;
}
